# Keil uVision project shutter_m3.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: shutter_m3
  c flags: Optim=3
  c include: ..\drivers;..\include;..\misc;..\bt\btm;..\bt\hci;..\bt\l2cap;..\bt\queue;..\bt\sdp;..\bt\hid
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../startup/: main.c startup_stm32f10x_hd.s
  group driver
    ../drivers/: delay.c sys.c uart.c beep.c key.c led.c
  group hci
    ../bt/hci/: hci.c hcitask.c
  group btm
    ../bt/btm/: btm_handle_hcievent.c btm_security.c btm.c
  group l2cap
    ../bt/l2cap/: l2cap.c
  group misc
    ../misc/: co_skbuff.c co_timer.c
  group hid
    ../bt/hid/: hid.c
  group sdp
    ../bt/sdp/: sdp.c
  group queue
    ../bt/queue/: queue.c buffer.c
  group Debug
    ../debug/: print.c
